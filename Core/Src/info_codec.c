/**
 ******************************************************************************
 * @file           : main.h
 * @brief          : Header for main.c file.
 *                   This file contains the common defines of the application.
 ******************************************************************************
 * @attention
 *
 * Portion Copyright (C) 2024 Semilla3 OÜ.  All Rights Reserved.
 *
 * This software is licensed under terms that can be found in the LICENSE file
 * in the root directory of this software component.
 * If no LICENSE file comes with this software, it is provided AS-IS.
 *
 ******************************************************************************
 */

#include "info_codec.h"

/*************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************/

/*
 * Internal helpers
 */

/**************************************************************************************************************************************
 ***** Function 	: N/A
 ***** Description 	: N/A
 ***** Parameters 	: N/A
 ***** Response 	: N/A
 **************************************************************************************************************************************/
static int in_u8(uint8_t v, uint8_t lo, uint8_t hi)
{
	return (v >= lo && v <= hi);
}

/**************************************************************************************************************************************
 ***** Function 	: N/A
 ***** Description 	: N/A
 ***** Parameters 	: N/A
 ***** Response 	: N/A
 **************************************************************************************************************************************/
enc_err_t enc_validate(const enc_fields_t *f)
{
	if(!f){
		return ENC_ERR_NULL;
	}

	if(!in_u8(f->f1, 0, 9) || !in_u8(f->f2, 0, 9) || !in_u8(f->f3, 0, 9)){
		return ENC_ERR_RANGE;
	}

	if(!in_u8(f->hw, 1, 9)){
		return ENC_ERR_RANGE;
	}

	if(!in_u8(f->mx, 1, 6) || !in_u8(f->my, 1, 6)){
		return ENC_ERR_RANGE;
	}

	if(!in_u8(f->p, 0, 1) || !in_u8(f->c, 0, 1) || !in_u8(f->b, 0, 1)){
		return ENC_ERR_RANGE;
	}

	return ENC_OK;
}

/**************************************************************************************************************************************
 ***** Function 	: N/A
 ***** Description 	: N/A
 ***** Parameters 	: N/A
 ***** Response 	: N/A
 **************************************************************************************************************************************/
static uint8_t enc_checksum(const enc_fields_t *f)
{
	uint16_t sum = (uint16_t) (f->f1 + f->f2 + f->f3 + f->hw + f->mx + f->my + f->p + f->c + f->b);

	return (uint8_t) (sum % 10);
}

/*************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************/

/*
 * Parse strict ASCII original:
 * "ENC,v1.2.0(2),M-6:3,P-0,C-1,BIT1"
 */

/**************************************************************************************************************************************
 ***** Function 	: N/A
 ***** Description 	: N/A
 ***** Parameters 	: N/A
 ***** Response 	: N/A
 **************************************************************************************************************************************/
static enc_err_t enc_parse_original(const char *s, enc_fields_t *out)
{
	if(!s || !out){
		return ENC_ERR_NULL;
	}

	size_t n = strlen(s);

	if(n < 30 || n > 40){
		return ENC_ERR_FMT;
	}

	if(strncmp(s, "ENC,v", 5) != 0){
		return ENC_ERR_FMT;
	}

	if((s[6] !='.')||(s[8]!='.')||(s[10]!='(')||(s[12]!=')')||(s[13]!=',')||(s[14]!='M')||(s[15]!='-')||(s[17]!=':')||(s[19]!=',')||(s[20]!='P')||(s[21]!='-')||(s[23]!=',')||(s[24]!='C')||(s[25]!='-')||(s[27]!=',')||(s[28]!='B')||(s[29]!='I')||(s[30]!='T')){
		return ENC_ERR_FMT;
	}

	char ch = s[5];

	if(ch < '0' || ch > '9'){
		return ENC_ERR_FMT;
	}

	out->f1 = ch - '0';
	ch = s[7];

	if(ch < '0' || ch > '9'){
		return ENC_ERR_FMT;
	}

	out->f2 = ch - '0';
	ch = s[9];

	if(ch < '0' || ch > '9'){
		return ENC_ERR_FMT;
	}

	out->f3 = ch - '0';
	ch = s[11];

	if(ch < '0' || ch > '9'){
		return ENC_ERR_FMT;
	}

	out->hw = ch - '0';
	ch = s[16];

	if(ch < '0' || ch > '9'){
		return ENC_ERR_FMT;
	}

	out->mx = ch - '0';
	ch = s[18];

	if(ch < '0' || ch > '9'){
		return ENC_ERR_FMT;
	}

	out->my = ch - '0';
	ch = s[22];

	if(ch < '0' || ch > '9'){
		return ENC_ERR_FMT;
	}

	out->p = ch - '0';
	ch = s[26];

	if(ch < '0' || ch > '9'){
		return ENC_ERR_FMT;
	}

	out->c = ch - '0';
	ch = s[31];

	if(ch < '0' || ch > '9'){
		return ENC_ERR_FMT;
	}

	out->b  = ch - '0';

	return enc_validate(out);
}

/*
 * Reduced token
 */

/**************************************************************************************************************************************
 ***** Function 	: N/A
 ***** Description 	: N/A
 ***** Parameters 	: N/A
 ***** Response 	: N/A
 **************************************************************************************************************************************/
enc_err_t enc_encode_fields_to_reduced(const enc_fields_t *f, char *out, size_t outCap)
{
	if(!f || !out){
		return ENC_ERR_NULL;
	}

	if(outCap < ENC_TOKEN_LEN + 1){
		return ENC_ERR_OUTCAP;
	}

	enc_err_t vr = enc_validate(f);

	if(vr != ENC_OK){
		return vr;
	}

	uint8_t k = enc_checksum(f);

	out[0]  = 'E';
	out[1]  = '0' + f->f1;
	out[2]  = '0' + f->f2;
	out[3]  = '0' + f->f3;
	out[4]  = '0' + f->hw;
	out[5]  = '0' + f->mx;
	out[6]  = '0' + f->my;
	out[7]  = '0' + f->p;
	out[8]  = '0' + f->c;
	out[9]  = '0' + f->b;
	out[10] = '0' + k;
	out[11] = '\0';

	return ENC_OK;
}

/**************************************************************************************************************************************
 ***** Function 	: N/A
 ***** Description 	: N/A
 ***** Parameters 	: N/A
 ***** Response 	: N/A
 **************************************************************************************************************************************/
enc_err_t enc_decode_reduced_to_fields(const char *reduced, enc_fields_t *out)
{
	if(!reduced || !out){
		return ENC_ERR_NULL;
	}

	if(strlen(reduced) != ENC_TOKEN_LEN){
		return ENC_ERR_FMT;
	}

	if(reduced[0] != 'E'){
		return ENC_ERR_FMT;
	}

	uint8_t d[10];

	for(int i = 1; i <= 10; i++)
	{
		char ch = reduced[i];

		if(ch < '0' || ch > '9'){
			return ENC_ERR_FMT;
		}

		d[i - 1] = (uint8_t) (ch - '0');
	}

	out->f1 = d[0];
	out->f2 = d[1];
	out->f3 = d[2];
	out->hw = d[3];
	out->mx = d[4];
	out->my = d[5];
	out->p  = d[6];
	out->c  = d[7];
	out->b  = d[8];

	uint8_t k = d[9];
	enc_err_t vr = enc_validate(out);

	if(vr != ENC_OK){
		return vr;
	}

	if(k != enc_checksum(out)){
		return ENC_ERR_CHECKSUM;
	}

	return ENC_OK;
}

/*************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************/

/*
 * ASCII original
 */

/**************************************************************************************************************************************
 ***** Function 	: N/A
 ***** Description 	: N/A
 ***** Parameters 	: N/A
 ***** Response 	: N/A
 **************************************************************************************************************************************/
enc_err_t enc_render_original(const enc_fields_t *f, char *out, size_t outCap)
{
	if(!f || !out){
		return ENC_ERR_NULL;
	}

	if(outCap < 64){
		return ENC_ERR_OUTCAP;
	}

	enc_err_t vr = enc_validate(f);

	if(vr != ENC_OK){
		return vr;
	}

	size_t pos = 0;

	memcpy(out + pos, "ENC,v", 5);
	pos += 5;

	out[pos++] = '0' + f->f1;
	out[pos++] = '.';
	out[pos++] = '0' + f->f2;
	out[pos++] = '.';
	out[pos++] = '0' + f->f3;
	out[pos++] = '(';
	out[pos++] = '0' + f->hw;
	out[pos++] = ')';
	out[pos++] = ',';
	out[pos++] = 'M';
	out[pos++] = '-';
	out[pos++] = '0' + f->mx;
	out[pos++] = ':';
	out[pos++] = '0' + f->my;
	out[pos++] = ',';
	out[pos++] = 'P';
	out[pos++] = '-';
	out[pos++] = '0' + f->p;
	out[pos++] = ',';
	out[pos++] = 'C';
	out[pos++] = '-';
	out[pos++] = '0' + f->c;
	out[pos++] = ',';
	out[pos++] = 'B';
	out[pos++] = 'I';
	out[pos++] = 'T';
	out[pos++] = '0' + f->b;
	out[pos] = '\0';

	return ENC_OK;
}

/*************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************
 *************************************************************************************************************************************************************************************************************/

/*
 * High-level API
 */

/**************************************************************************************************************************************
 ***** Function 	: N/A
 ***** Description 	: N/A
 ***** Parameters 	: N/A
 ***** Response 	: N/A
 **************************************************************************************************************************************/
enc_err_t enc_encode_original_to_reduced(const char *original, char *outReduced, size_t outCap)
{
	enc_fields_t f;
	enc_err_t pr = enc_parse_original(original, &f);

	if(pr != ENC_OK){
		return pr;
	}

	return enc_encode_fields_to_reduced(&f, outReduced, outCap);
}

/**************************************************************************************************************************************
 ***** Function 	: N/A
 ***** Description 	: N/A
 ***** Parameters 	: N/A
 ***** Response 	: N/A
 **************************************************************************************************************************************/
enc_err_t enc_decode_reduced_to_original(const char *reduced, char *outOriginal, size_t outCap)
{
	enc_fields_t f;
	enc_err_t dr = enc_decode_reduced_to_fields(reduced, &f);

	if(dr != ENC_OK){
		return dr;
	}

	return enc_render_original(&f, outOriginal, outCap);
}

/**************************************************************************************************************************************
 ***** Function 	: N/A
 ***** Description 	: N/A
 ***** Parameters 	: N/A
 ***** Response 	: N/A
 **************************************************************************************************************************************/
enc_err_t enc_convert_either_way(const char *input, char *out, size_t outCap)
{
	if(!input || !out){
		return ENC_ERR_NULL;
	}

	if(strncmp(input, "ENC,", 4) == 0){
		return enc_encode_original_to_reduced(input, out, outCap);
	}

	if(strlen(input) == ENC_TOKEN_LEN && input[0] == 'E'){
		return enc_decode_reduced_to_original(input, out, outCap);
	}

	return ENC_ERR_FMT;
}






